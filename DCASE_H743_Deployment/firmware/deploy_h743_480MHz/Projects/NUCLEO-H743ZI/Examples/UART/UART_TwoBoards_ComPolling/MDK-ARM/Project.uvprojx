# Keil uVision project Project.uvprojx, settings and files
target STM32H743ZI-Nucleo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743ZI-Nucleo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H7XX_NUCLEO_144_MB1364,ARM_MATH_CM7
  c misc: --C99
  c include: ../Inc;../Dsp;../Model;../AI;../cmsis_dsp/Inc;../cmsis_dsp/Src;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\app.sct
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_dma.c stm32h7xx_hal_exti.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Example/MDK-ARM
    ./: startup_stm32h743xx.s
  group Example/User
    ../Src/: stm32h7xx_hal_msp.c main.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/stm32h7xx_nucleo
    ../../../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Dsp
    ../Dsp/: logmel.c mel_filter.c
  group Model
    ../Model/: network.c network_data.c network_data_params.c
  group CMSIS-DSP
    ../cmsis_dsp/Src/: CommonTables.c TransformFunctions.c BasicMathFunctions.c ComplexMathFunctions.c FastMathFunctions.c MatrixFunctions.c StatisticsFunctions.c
  group AI-Runtime
    ../Lib/: NetworkRuntime1020_CM7_Keil.lib
software components: CMSIS:CORE 4.3.0
